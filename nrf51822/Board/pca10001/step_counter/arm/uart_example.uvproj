# Keil uVision project uart_example.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: main.c sensor.c step.c rtc.c data_transfer.c flash.c
  group Services
    ../: ble_nus.c
    ../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c
  group Libraries
    ../../../../Source/ble/: ble_error_log.c ble_debug_assert_handler.c ble_conn_params.c ble_advdata.c
    ../../../../Source/app_common/: app_timer.c pstorage.c
    ../../../../Source/simple_uart/: simple_uart.c
    ../: ble_flash.c twi_hw_master_SD_4_4.c
    ../../../../Source/sd_common/: softdevice_handler.c
    ../../../../Source/ble/ble_services/: ble_srv_common.c
  group History
    ../../../../Release/: History_W1FW.txt
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: W1FW +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PROJECT_W1 BLE_STACK_SUPPORT_REQD DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\include;..\include;..\..\..\..\Include\app_common;..\..\..\..\Include\ble;..\..\..\..\Include\ble\ble_services;..\..\..\..\Include\ble\softdevice;..\..\..\..\Include\sd_common;..\..\..\..\include\boards
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
